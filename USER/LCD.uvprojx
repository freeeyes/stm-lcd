# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\SCREEN;..\uIP-1.0\uip;..\APP\spi;..\Public;..\APP\ENC28J60;..\HARDWARE\Dog;..\APP\ball;..\APP\time;..\APP\rtc;..\APP\adc;..\APP\adc_temp;..\uIP-APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c ring.c key.c
    ../STM32F10x_FWLib/src/: stm32f10x_fsmc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SCREEN/: tftlcd.c
    ../HARDWARE/Dog/: wdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group README
    ../: README.TXT
  group APP
    ../APP/ENC28J60/: enc28j60.c
    ../APP/spi/: spi.c
    ../APP/time/: time.c
    ../APP/adc/: adc.c
    ../APP/adc_temp/: adc_temp.c
    ../APP/rtc/: rtc.c
  group Public
    ../Public/: system.c SysTick.c usart.c
  group uIP-APP
    ../uIP-APP/: clock-arch.c tapdev.c tcp_client_demo.c tcp_demo.c tcp_server_demo.c
  group uIP
    ../uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
